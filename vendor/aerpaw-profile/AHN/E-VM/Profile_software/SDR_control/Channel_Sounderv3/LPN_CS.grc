options:
  parameters:
    generate_options: no_gui
    id: LPN_CS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.99'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: SounderRX_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq1
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq2
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq3
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq4
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq5
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq6
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq7
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq8
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0_0_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq9
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0_0_0_0_0_0_0_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq10
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderTX_0
  id: SounderTX
  parameters:
    alpha: alpha
    freq: txfreq
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: args
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/Power1
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power2
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality1
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality2
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality3
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality4
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality5
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality6
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality7
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality8
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality9
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality10
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /root/Power3
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /root/Power4
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power5
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power6
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power7
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power8
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power9
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power10
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/1.58
    type: complex
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 3.32e9
  states: {}
- name: gainrx
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: gaintx
  id: parameter
  parameters:
    type: eng_float
    value: '76'
  states: {}
- name: rxfreq1
  id: parameter
  parameters:
    type: eng_float
    value: 812.5e3
  states: {}
- name: rxfreq10
  id: parameter
  parameters:
    type: eng_float
    value: '-812.5e3'
  states: {}
- name: rxfreq2
  id: parameter
  parameters:
    type: eng_float
    value: '-312.5e3'
  states: {}
- name: rxfreq3
  id: parameter
  parameters:
    type: eng_float
    value: 687.5e3
  states: {}
- name: rxfreq4
  id: parameter
  parameters:
    type: eng_float
    value: '-437.5e3'
  states: {}
- name: rxfreq5
  id: parameter
  parameters:
    type: eng_float
    value: 562.5e3
  states: {}
- name: rxfreq6
  id: parameter
  parameters:
    type: eng_float
    value: '-562.5e3'
  states: {}
- name: rxfreq7
  id: parameter
  parameters:
    type: eng_float
    value: 437.5e3
  states: {}
- name: rxfreq8
  id: parameter
  parameters:
    type: eng_float
    value: '-687.5e3'
  states: {}
- name: rxfreq9
  id: parameter
  parameters:
    type: eng_float
    value: 312.5e3
  states: {}
- name: txfreq
  id: parameter
  parameters:
    type: eng_float
    value: 187.5e3
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_source0: external
    dev_args: args
    gain0: gaintx
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dev_args: args
    gain0: gainrx
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [SounderRX_0, '0', blocks_file_sink_0, '0']
- [SounderRX_0, '1', blocks_file_sink_0_0_0, '0']
- [SounderRX_0_0, '0', blocks_file_sink_0_0, '0']
- [SounderRX_0_0, '1', blocks_file_sink_0_0_0_0, '0']
- [SounderRX_0_0_0, '0', blocks_file_sink_0_0_1, '0']
- [SounderRX_0_0_0, '1', blocks_file_sink_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0, '0', blocks_file_sink_0_0_1_0, '0']
- [SounderRX_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0_0, '0']
- [SounderRX_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0_0_0_0, '0']
- [SounderRX_0_0_0_0_0_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [SounderTX_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0_0_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', SounderRX_0_0_0_0_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
