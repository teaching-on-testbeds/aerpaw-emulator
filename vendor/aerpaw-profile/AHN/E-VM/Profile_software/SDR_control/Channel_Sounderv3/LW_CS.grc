options:
  parameters:
    generate_options: no_gui
    id: LW_CS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.99'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: SounderRX_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderRX_0_0
  id: SounderRX
  parameters:
    fcut: 62.5e3
    freq: rxfreq
    ftrans: 20e3
    gainrx: gainrx
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderTX_0
  id: SounderTX
  parameters:
    alpha: alpha
    freq: txfreq1
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: SounderTX_0_0
  id: SounderTX
  parameters:
    alpha: alpha
    freq: txfreq2
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: args
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/Power1
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Power2
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality1
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality2
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/1.58
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/1.58
    type: complex
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 3.32e9
  states: {}
- name: gainrx
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: gaintx
  id: parameter
  parameters:
    type: eng_float
    value: '76'
  states: {}
- name: rxfreq
  id: parameter
  parameters:
    type: eng_float
    value: 187.5e3
  states: {}
- name: txfreq1
  id: parameter
  parameters:
    type: eng_float
    value: 812.5e3
  states: {}
- name: txfreq2
  id: parameter
  parameters:
    type: eng_float
    value: '-312.5e3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dev_args: args
    gain0: gaintx
    gain1: gaintx
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_args: args
    gain0: gainrx
    gain1: gainrx
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [SounderRX_0, '0', blocks_file_sink_0, '0']
- [SounderRX_0, '1', blocks_file_sink_0_0_0, '0']
- [SounderRX_0_0, '0', blocks_file_sink_0_0, '0']
- [SounderRX_0_0, '1', blocks_file_sink_0_0_0_0, '0']
- [SounderTX_0, '0', blocks_multiply_const_vxx_0, '0']
- [SounderTX_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_1, '0', SounderRX_0, '0']
- [uhd_usrp_source_1, '1', SounderRX_0_0, '0']

metadata:
  file_format: 1
